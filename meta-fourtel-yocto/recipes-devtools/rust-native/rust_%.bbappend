# Ensure that libstdc++ is available as a build-time dependency
#DEPENDS += "libstdc++"

# Append the C++ standard library to the linker flags
#LDFLAGS += " -lstdc++"


# meta-mycustom/recipes-devtools/rust-native/rust-native_1.68.2-r0.bbappend

# Ensure that libstdc++-dev-native is available as a build-time dependency
#DEPENDS += "gcc-native libstdc++-dev-native"

# Append the C++ standard library to the linker flags
#LDFLAGS += " -lstdc++"
